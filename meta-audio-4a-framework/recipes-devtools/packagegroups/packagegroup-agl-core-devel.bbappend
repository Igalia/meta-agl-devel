RDEPENDS_${PN}_append = " 4a-tools"
